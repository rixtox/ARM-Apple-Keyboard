# Keil uVision project ARM_Apple_Keyboard.uvprojx, settings and files
target ARM_Apple_Keyboard Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  output: ARM_Apple_Keyboard.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK22FN512VLH12
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186,66,111,223  --library_interface=armcc
  c include: ../../..; ../devices/MK22F51212/drivers; ../devices/MK22F51212/utilities; ../devices/MK22F51212; ../devices/MK22F51212/arm; ../CMSIS/Include; ../../; ../
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x80000
  memory RVCT9: RAM 0x1FFF0000 size 0x00010000
  memory RVCT10: RAM 0x20000000 size 0x00010000
  scatter file: MK22FN512xxx12_flash.scf
  group startup
    ../devices/MK22F51212/arm/: startup_MK22F51212.s
    ../devices/MK22F51212/: system_MK22F51212.c system_MK22F51212.h
  group CMSIS
    ../CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armcc_V6.h cmsis_gcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h core_cm4.h
    ../devices/MK22F51212/: fsl_device_registers.h MK22F51212.h MK22F51212_features.h
  group drivers
    ../devices/MK22F51212/drivers/: fsl_rcm.c fsl_rcm.h fsl_flexbus.c fsl_flexbus.h fsl_wdog.c fsl_wdog.h fsl_llwu.c fsl_llwu.h fsl_smc.c fsl_smc.h fsl_rnga.c fsl_rnga.h fsl_ftm.c fsl_ftm.h fsl_port.h fsl_adc16.c fsl_adc16.h fsl_edma.c fsl_edma.h fsl_crc.c fsl_crc.h fsl_lptmr.c fsl_lptmr.h fsl_uart.c fsl_uart_edma.c fsl_uart.h fsl_uart_edma.h fsl_dac.c fsl_dac.h fsl_gpio.c fsl_gpio.h fsl_dmamux.c fsl_dmamux.h fsl_vref.c fsl_vref.h fsl_clock.c fsl_clock.h fsl_ewm.c fsl_ewm.h fsl_lpuart.c fsl_lpuart_edma.c fsl_lpuart.h fsl_lpuart_edma.h fsl_pmc.c fsl_pmc.h fsl_pit.c fsl_pit.h fsl_i2c.c fsl_i2c_edma.c fsl_i2c.h fsl_i2c_edma.h fsl_cmp.c fsl_cmp.h fsl_rtc.c fsl_rtc.h fsl_pdb.c fsl_pdb.h fsl_flash.c fsl_flash.h fsl_dspi.c fsl_dspi_edma.c fsl_dspi.h fsl_dspi_edma.h fsl_sim.c fsl_sim.h fsl_common.c fsl_common.h fsl_sai.c fsl_sai_edma.c fsl_sai.h fsl_sai_edma.h
  group utilities
    ../devices/MK22F51212/utilities/: fsl_notifier.c fsl_notifier.h fsl_sbrk.c fsl_debug_console.c fsl_debug_console.h
  group board
    ../: board.c board.h pin_mux.c pin_mux.h clock_config.c clock_config.h
  group sources
    ../: main.c
  group linker
    ./: MK22FN512xxx12_flash.scf
target ARM_Apple_Keyboard Release (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  output: ARM_Apple_Keyboard.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK22FN512VLH12
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  --library_interface=armcc
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x80000
  memory RVCT9: RAM 0x1FFF0000 size 0x00010000
  memory RVCT10: RAM 0x20000000 size 0x00010000
  scatter file: MK22FN512xxx12_flash.scf
